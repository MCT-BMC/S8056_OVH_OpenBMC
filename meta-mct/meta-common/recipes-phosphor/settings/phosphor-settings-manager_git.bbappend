FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"
SRC_URI:append = " file://timeowner-host-no-ntp.override.yml"
