FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-defconfig-takes-precedence-over-than-other.patch"
