FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ast-soc-define.patch \
            file://0002-ast-uboot-i2c-driver.patch \
            "

