FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "a5deeeafe84893722d601b2343943eb78f263e4f"
SRC_URI += "file://0001-Implement-KVM-in-webui.patch"

