FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-SEL-log-for-Power-Button-Press.patch"

