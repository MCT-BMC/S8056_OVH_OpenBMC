FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-support-ipmi-chassis-reset-command.patch \
            file://0003-Implement-master-write-read-command.patch \ 
            "


