FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-s7106-update-ME-channel-config-of-new-ipmb-service.patch"

