PHOSPHOR_DBUS_MONITOR_CONFIGS_append = "s7106-event-policy-native"
