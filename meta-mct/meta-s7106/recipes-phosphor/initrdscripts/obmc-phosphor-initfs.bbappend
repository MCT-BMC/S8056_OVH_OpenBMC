FILESEXTRAPATHS_prepend_s7106 := "${THISDIR}/${PN}:"
