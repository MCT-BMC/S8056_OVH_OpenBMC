RDEPENDS_${PN}-chassis += " \
                            obmc-phosphor-buttons-signals \
                            obmc-phosphor-buttons-handler \
                            "
