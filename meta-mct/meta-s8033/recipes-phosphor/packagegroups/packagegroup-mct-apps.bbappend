RDEPENDS:${PN}-chassis:remove = " obmc-op-control-power"
