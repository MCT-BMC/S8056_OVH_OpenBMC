FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ignore-power-policy-when-BMC-reset.patch \
           "

