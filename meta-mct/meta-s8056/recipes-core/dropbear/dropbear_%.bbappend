FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

BINCOMMANDS = "scp"