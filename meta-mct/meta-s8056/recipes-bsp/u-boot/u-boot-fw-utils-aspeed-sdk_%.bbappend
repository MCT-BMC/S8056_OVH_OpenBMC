FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"