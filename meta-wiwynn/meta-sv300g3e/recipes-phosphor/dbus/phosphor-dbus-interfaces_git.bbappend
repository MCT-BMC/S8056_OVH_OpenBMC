FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-property-for-power-on-dealy-policy.patch \
           "
