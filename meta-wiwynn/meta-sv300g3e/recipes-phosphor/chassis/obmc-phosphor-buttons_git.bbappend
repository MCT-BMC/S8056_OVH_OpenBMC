FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-SEL-entries-for-button-pressed-events.patch \
           "
