FILESEXTRAPATHS_prepend_sv300g3e := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-netipmid-Skip-SOL-payload-activation-checking.patch \
           "
