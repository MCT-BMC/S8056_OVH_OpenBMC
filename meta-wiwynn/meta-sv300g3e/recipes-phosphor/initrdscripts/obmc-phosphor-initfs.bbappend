FILESEXTRAPATHS_prepend_sv300g3e := "${THISDIR}/${PN}:"
