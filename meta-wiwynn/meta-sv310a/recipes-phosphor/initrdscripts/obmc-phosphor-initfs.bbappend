FILESEXTRAPATHS_prepend_sv310a := "${THISDIR}/${PN}:"

SRC_URI += "file://whitelist"
