FILESEXTRAPATHS_prepend_sv310a := "${THISDIR}/${PN}:"
