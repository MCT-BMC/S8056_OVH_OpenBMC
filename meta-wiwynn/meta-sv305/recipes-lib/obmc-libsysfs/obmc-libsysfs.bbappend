EXTRA_OECMAKE+= "-DMOTHERBOARD_CONFIG_PATH=/usr/share/entity-manager/configurations/sv305-MB.json"
