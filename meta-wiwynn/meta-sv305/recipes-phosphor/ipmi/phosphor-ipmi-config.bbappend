FILESEXTRAPATHS_prepend_sv305 := "${THISDIR}/${PN}:"
