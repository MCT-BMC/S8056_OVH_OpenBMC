RDEPENDS_${PN}-chassis += " \
                          "
