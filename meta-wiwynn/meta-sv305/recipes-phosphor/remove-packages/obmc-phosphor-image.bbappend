IMAGE_FEATURES_remove += " \
    obmc-ikvm \
    "
