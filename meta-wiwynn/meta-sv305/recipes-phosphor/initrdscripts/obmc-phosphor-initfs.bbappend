FILESEXTRAPATHS_prepend_sv305 := "${THISDIR}/${PN}:"

SRC_URI += "file://whitelist"
