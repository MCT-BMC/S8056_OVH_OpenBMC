FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Revise-max-post-code-cycles.patch \
            file://0002-Fix-the-memory-overflow-issue.patch \
           "

